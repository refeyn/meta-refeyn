OS_RELEASE_FIELDS += " IMAGE_VERSION MACHINE"
