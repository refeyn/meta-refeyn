SRCBRANCH = "refeyn-lf-6.1.y"
KERNEL_SRC = "git://git@github.com/refeyn/linux-imx.git;protocol=ssh;branch=${SRCBRANCH}"
SRCREV = "1e8ea3ab35816e702e049a40dde355bb29443a0f"
