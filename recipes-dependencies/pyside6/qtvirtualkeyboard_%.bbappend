VKB_LANGUAGES = "lang-en_GB lang-en_US"
BBCLASSEXTEND = "native nativesdk"
