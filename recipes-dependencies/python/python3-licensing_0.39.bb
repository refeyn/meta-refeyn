DESCRIPTION = "Client library for Cryptolens licensing Web API."
HOMEPAGE = "https://cryptolens.io/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=9b12fbd0b0717d1ec926c48495049b98"

SRC_URI[sha256sum] = "b0c61c0047502e10bc4a6b16ef3d412820288e0d419347a936fde5cdd17bf14b"

inherit pypi python_setuptools_build_meta
