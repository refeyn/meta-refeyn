PACKAGECONFIG = "gstreamer qml"
