RDEPENDS:${PN} += " \
	python3-appdirs \
	python3-flexcache \
	python3-flexparser \
"
