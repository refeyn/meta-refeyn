PV = "2.13.6"
SRCREV = "a2e59f0e7065404b44dfe92a28aca47ba1378dc4"
SRC_URI:remove = "file://avoid-host-includes.patch"
