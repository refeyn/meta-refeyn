BBCLASSEXTEND = "native nativesdk"
PACKAGECONFIG:class-native = "qml spatialaudio spatialaudio_quick3d"
