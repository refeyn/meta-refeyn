EXTRA_OECMAKE += "-DHDF5_ENABLE_Z_LIB_SUPPORT=ON"
DEPENDS += "zlib"
