DEPENDS = ""
EXTRA_OECMAKE = "-DDISABLE_EXTERNAL_LIBS=ON"
