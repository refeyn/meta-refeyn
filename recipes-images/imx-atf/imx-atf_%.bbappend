EXTRA_OEMAKE += "IMX_DEBUG_UART=1 DEBUG_CONSOLE=0"
