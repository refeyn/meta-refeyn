UBOOT_SRC = "git://git@github.com/refeyn/uboot-imx.git;protocol=ssh"
SRCBRANCH = "refeyn-lf_v2022.04"
SRCREV = "fff82013cd8d816bf405dd89f9980a08ecbb48d9"
