# https://github.com/zboszor/meta-python-ai?tab=readme-ov-file#installation
# Affinity removed as it messes with the cores that AMP uses
PACKAGECONFIG = "lapack cblas dynarch"
