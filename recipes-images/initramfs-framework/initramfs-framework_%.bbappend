RDEPENDS:initramfs-module-kmod:remove = "kernel-module-sii902x"
