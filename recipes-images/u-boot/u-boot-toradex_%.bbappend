SRC_URI = "git://git@github.com/refeyn/u-boot.git;protocol=ssh;branch=${SRCBRANCH}"
SRCREV = "00a40c7f7533d85891b3f7731090486837c5b688"
SRCBRANCH = "refeyn_imx_lf_v2024.04"
COMPATIBLE_MACHINE = "apalis-imx8-refeyn"
