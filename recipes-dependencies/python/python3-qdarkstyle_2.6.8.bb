DESCRIPTION = "A dark stylesheet for Python and Qt applications"
HOMEPAGE = "https://github.com/ColinDuquesnoy/QDarkStyleSheet"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=bab2f4bf1dfe611250ede46dabedaa20"
PYPI_PACKAGE = "QDarkStyle"

SRC_URI[sha256sum] = "037a54bf0aa5153f8055b65b8b36ac0d0f7648f2fd906c011a4da22eb0f582a2"

inherit pypi python_setuptools_build_meta
