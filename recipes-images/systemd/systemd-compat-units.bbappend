# discrepancy
# ./openembedded-core/meta/recipes-core/systemd/systemd-compat-units.bb 
# ./openembedded-core/meta/recipes-devtools/run-postinsts/run-postinsts_1.0.bb 
# ./openembedded-core/meta/recipes-devtool/opkg/opkg.inc
POSTINSTALL_INITPOSITION = "99"
